# Keil uVision project spi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: spi
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s core_cm3.h core_cm3.c main.c system_LPC17xx.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_uart.c Retarget.c Serial.c lpc17xx_pinsel.c hardware.c
